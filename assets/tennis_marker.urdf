Commit message: datasets added

File: assets/tennis_marker.urdf (robot description, URDF)
Before this commit: robot object, 1 links, 0 joints
Links:
- link object: geometry collision sphere radius=0.055; visual sphere radius=0.04
